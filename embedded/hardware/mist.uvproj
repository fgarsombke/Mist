# Keil uVision project mist.uvproj, settings and files
target lm3s811 (ARM-ADS)
  device: LM3S811 Texas Instruments
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: mist
  AfterMake: fromelf --bin --output .\mist.bin .\mist.axf
  c flags: OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S811
  c include: ..;..\..\..;.\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: mist.sct
  link misc: --entry Reset_Handler
  group src
    ./src/: zone.c main.c schedule.c wifly.c startup_rvmdk.S fifo.c uart.c SystemClock.c
    ../drivers/: rit128x96x4.c
  group inc
    ./inc/: zone.h FIFO.h schedule.h wifly.h uart.h SystemClock.h
    ../drivers/: rit128x96x4.h
  group lib
    ../driverlib/rvmdk/: driverlib.lib

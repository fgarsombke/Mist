# Keil uVision project mist.uvproj, settings and files
target lm3s811 (ARM-ADS)
  device: LM3S811 Texas Instruments
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: mist
  AfterMake: fromelf --bin --output .\mist.bin .\mist.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S811
  c include: ..;..\..\..;.\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: mist.sct
  link misc: --entry Reset_Handler
  group src
    ./src/: zone.c main.c schedule.c wifly.c startup_rvmdk.S fifo.c uart.c json.c jsmn.c system_clock.c file_system.c flash_prog.c
  group inc
    ./inc/: zone.h schedule.h wifly.h uart.h json.h jsmn.h system_clock.h fifo.h
    ../drivers/: rit128x96x4.h
  group lib
    ../driverlib/rvmdk/: driverlib.lib

# Keil uVision project demo.uvproj, settings and files
target demo (ARM-ADS)
  device: LM3S811 Texas Instruments
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: demo
  AfterMake: fromelf --bin --output .\demo.bin .\demo.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S1968
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: demo.sct
  link misc: --entry Reset_Handler
  group source
    ./: demo.c startup_rvmdk.S zone.c
  group libs
    ../driverlib/rvmdk/: driverlib.lib

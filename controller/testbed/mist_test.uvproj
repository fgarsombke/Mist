# Keil uVision project mist_test.uvproj, settings and files
target mist_test (ARM-ADS)
  device: LM3S1968 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: mist_test
  AfterMake: fromelf --bin --output .\mist_test.bin .\mist_test.axf
  c flags: Optim=3 OneElfS=1
  c define: rvmdk PART_LM3S1968
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: mist_test.sct
  link misc: --entry Reset_Handler
  group source
    ./: zone.c main.c startup_rvmdk.S wifly.c FIFO.h rgb_led.c
    ../drivers/: rit128x96x4.c
  group lib
    ../driverlib/rvmdk/: driverlib.lib
